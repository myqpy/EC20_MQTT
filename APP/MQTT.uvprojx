# Keil uVision project MQTT.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32EC20 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\APP;..\STM32F10x_FWLib\inc;..\CM3;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\USART2;..\SIM800C;..\HARDWARE\USART4;..\LCD5110;..\HTTP;..\HARDWARE\EC20;..\HARDWARE\MODBUS;..\SYSTEM\bsp_uart;..\SYSTEM\CJSON;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./: main.c stm32f10x_it.c system_stm32f10x.c service.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/MODBUS/: MODBUS.C
    ../HARDWARE/EC20/: EC20.c
    ../HARDWARE/USART4/: usart4.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/bsp_uart/: bsp_usart.c
  group CM3
    ../CM3/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c
  group cJson
    ../SYSTEM/CJSON/: cJSON.c cJSON_Utils.c
